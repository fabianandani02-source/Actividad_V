# Keil uVision project usart_mio.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usart_mio
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: comms.c prng2000.c sram_pool.c indicator.c mode_poll.c mode_dma.c main.c
  group includes Group
    ./: comms.h prng2000.h sram_pool.h indicator.h mode_poll.h mode_dma.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
